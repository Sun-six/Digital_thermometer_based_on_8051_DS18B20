# Keil uVision project 8051_or_ds18b20.uvproj, settings and files
target ds18b20 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 8051_or_ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Module
  group USER
    ./: STARTUP.A51
    ./User/: main.c
  group MODULE
    ./Module/: ds18b20.c digital_tube.c delay.c
